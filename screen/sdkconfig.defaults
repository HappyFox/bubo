## screen/sdkconfig.defaults
```kconfig
CONFIG_TINYUSB_CDC_ENABLED=y
# CONFIG_LCD_RGB_RESTART_IN_VSYNC is not set
CONFIG_FLASH_ESPDET_PICO_224_224_FACE=y
CONFIG_ESPDET_PICO_224_224_FACE=y
```
